# Keil uVision project Project.uvprojx, settings and files
target HK32F030MF4P6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HK32F030MF4P6 HK_MicroChip
  pack: HKMicroChip.HK32F030xMxx_DFP.1.0.17
  cpu: IRAM(0x20000000,0x800) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HK32F030MF4P6,HK32F030MXX,USE_HK32F030xMF4P6_EVAL,USE_DEFAULT_TIMEOUT_CALLBACK
  c include: ..\Libraries\CMSIS\CM0\Core;..\Libraries\CMSIS\HK32F030M\Include;..\Libraries\CMSIS\HK32F030M\Source;..\Libraries\CMSIS\HK32F030M\Source\ARM;..\Libraries\HK32F030Mxx_StdPeriph_Driver\inc;..\Libraries\HK32F030Mxx_StdPeriph_Driver\src;..\inc;..\src;..\Boards\Board_HK32F030xMF4P6_EVAL\inc;..\Boards\Board_HK32F030xMF4P6_EVAL\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group CMSIS
    ../Libraries/CMSIS/HK32F030M/Source/ARM/: KEIL_Startup_hk32f030m.s
    ../Libraries/CMSIS/HK32F030M/Source/: system_hk32f030m.c
  group User
    ../src/: hk32f030m_it.c main.c
  group StdPeriph_Driver
    ../Libraries/HK32F030Mxx_StdPeriph_Driver/src/: hk32f030m_adc.c hk32f030m_awu.c hk32f030m_beep.c hk32f030m_crc.c hk32f030m_dbgmcu.c hk32f030m_exti.c hk32f030m_flash.c hk32f030m_gpio.c hk32f030m_i2c.c hk32f030m_iwdg.c hk32f030m_misc.c hk32f030m_pwr.c hk32f030m_rcc.c hk32f030m_spi.c hk32f030m_syscfg.c hk32f030m_tim.c hk32f030m_usart.c hk32f030m_wwdg.c
  group Board
    ../Boards/Board_HK32F030xMF4P6_EVAL/src/: hk32f030xmf4p6_eval.c hk32f030xmf4p6_eval_i2c_ee.c hk32f030xmf4p6_eval_spi_flash.c
